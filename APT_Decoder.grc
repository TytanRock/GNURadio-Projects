options:
  parameters:
    author: Cory
    generate_options: qt_gui
    id: Apt_Decoder
    output_language: python
    title: NOAA APT Decoder
  states: {}

blocks:
- name: high_cutoff
  id: variable_qtgui_range
  parameters:
    label: High_Cutoff
    orient: Qt.Horizontal
    start: 2e3
    step: '1'
    stop: 10e3
    value: 4.9e3
  states: {}
- name: low_cutoff
  id: variable_qtgui_range
  parameters:
    label: Low_Cutoff
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 2e3
    value: '500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '220500'
  states: {}
- name: satellite
  id: variable_qtgui_chooser
  parameters:
    label0: NOAA 15
    label1: NOAA 19
    labels: '["NOAA 15", "NOAA 19"]'
    num_opts: '2'
    option0: '137620000'
    option1: '137100000'
    options: '[137620000, 137100000]'
    type: int
    value: '137620000'
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    label: Transition_Width
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 1e3
    value: '200'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    min_len: '1'
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: high_cutoff
    low_cutoff_freq: low_cutoff
    samp_rate: '22050'
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\Users\Cory\Documents\gnuradio\out.dat
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '255'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '1'
    type: float
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '7762'
    psize: '2080'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Use this source instead of the 
      demodulated output if you 
      want to just test that the 
      decoding works
    file: D:\Users\Cory\Documents\gnuradio\argentina.wav
    repeat: 'False'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: satellite
    fftsize: '1024'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Decoding algorithm taken from:
      https://oz9aec.net/radios/gnu-radio/simple-apt-decoder-prototype
    decim: '11025'
    interp: '9600'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '4800'
    interp: '4160'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    bw0: 200e3
    freq0: satellite
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_null_sink_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_1, '0']
- [blocks_float_to_complex_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_udp_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_complex_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', blocks_keep_one_in_n_0, '0']
- [rational_resampler_xxx_0, '0', blocks_skiphead_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', analog_fm_demod_cf_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
